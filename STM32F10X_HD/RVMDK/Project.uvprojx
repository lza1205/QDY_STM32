# Keil uVision project Project.uvprojx, settings and files
target STM32F10X_HD (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10X_HD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c misc: --C99
  c include: ..\;..\Src;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Src\include;..\Src\BSP\SysTick;..\Src\BSP\TIMER;..\Src\BSP\USART;..\Src\BSP\USART;..\Src\network;..\Src\example\qdy;..\Src\sys;..\Src\BSP\gpio;..\Src\sys\command;..\Src\example\RS485_LCD;..\Src\BSP\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\Output\STM32F10X_HD\STM32F10X_HD.sct
  group Main
    ../Src/Wizard_STM32_Init/: STM32_Init.c
    ../Src/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DeviceSupport
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ./: KeilConfig.txt
  group bsp
    ../Src/BSP/SysTick/: SysTick.c
    ../Src/BSP/TIMER/: timer.c
    ../Src/BSP/USART/: usart.c
    ../Src/BSP/gpio/: gpio.c
    ../Src/BSP/motor/: motor.c
    ../Src/BSP/RTC/: RTC.c
  group network
    ../Src/network/: esp8266.c gsm_base.c gsm_code.c network_api.c nbiot_bc26.c
  group sys
    ../Src/sys/: sysconfig.c qdy_system.c my_list.c timer_list.c
    ../Src/sys/command/: command.c command_server.c
  group exsaple_RS485
    ../Src/example/RS485_LCD/: uart_lcd.c rs485_sensor.c
